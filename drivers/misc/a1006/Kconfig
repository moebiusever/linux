## drivers/misc/a1006/Kconfig
```kconfig
#
# forlinx  drivers a1006
#
menu "Forlinx a1006"
config a1006
    bool "a1006 driver"
    default y
    
	help
		a1006
endmenu
```
